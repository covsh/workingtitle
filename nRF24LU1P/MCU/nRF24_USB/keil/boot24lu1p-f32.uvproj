# Keil uVision project boot24lu1p-f32.uvproj, settings and files
target Target 1 (MCS-51)
  device: nRF24LU1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: boot24lu1p-f32 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\..\..\hal;..\..\..\hal\nrf24lu1p;..\..\..\compiler\c51;..\..\..\compiler\common;..\TPF;
  link misc: REMOVEUNUSED
  group Application
    ../: main.c usb.c bootloader.c usb_desc_bootloader.c STARTUP.A51 uart_woisr.c
  group HAL
    ../../../hal/nrf24lu1p/: hal_uart.c
  group TFP
    ../TPF/: printf.c
